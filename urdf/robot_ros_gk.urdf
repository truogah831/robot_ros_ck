Commit message: update

File: urdf/robot_ros_gk.urdf (robot description, URDF)
Before this commit: robot robot_ros_gk, 12 links, 11 joints
Joints:
- joint banhphaisau_link_joint: axis 0 0 1 -> 0 0 -1
- joint banhtraisau_link_joint: axis 0 0 1 -> 0 0 -1
